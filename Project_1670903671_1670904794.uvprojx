# Keil uVision project Project_1670903671_1670904794.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_1670903671_1670904794
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: mainProjectCode.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
